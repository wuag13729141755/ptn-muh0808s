# Keil uVision project Project_GD32F4XX.uvprojx, settings and files
target N32G45X_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  AfterMake: HeBin_N32G45X.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\CMSIS_N32G45X\CMSIS\core;..\CMSIS_N32G45X\CMSIS\device;..\CMSIS_N32G45X\n32g45x_usbfs_driver\inc;..\CMSIS_N32G45X\n32g45x_std_periph_driver\inc;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/flash/: drv_Flash.c
  group BSP
    ../BSP/: bsp.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FreeRTOS/PortCM4
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group USER
    ../USER/: main.c Task_Led.c Task_Key.c Task_IR.c Task_Eeprom.c Task_ITE663XX.c Task_ITE6664.c Task_Uart.c Task_CEC.c Task_UsbDect.c ITE663XX_comm_api.c ITE663XX_func_api.c ITE6664_comm_api.c ITE6664_func_api.c I2C_Driver.c ITE_comm_api.c SPI_Driver.c Key_Response_Comm.c printf.c Task_CheckChipID.c Task_ExternalChip.c Task_Gsv2kx.c Task_INV767X.c
    ../USER/eeprom/: Eeprom.c
    ../USER/external_chip/: mdrv_ExternalChipDriver.c
    ../USER/Task_Function/: Task_VideoC1.c
  group ITE66321_Customer
    ../USER/video_chip/: it663xx_customer_c_file.c
  group ITE66321_Source
    ../USER/video_chip/: it663xx_source_c_file.c
  group ITE6664
    ../USER/video_chip/: it666x_c_file.c
  group MN86478X_APL
    ../USER/VideoChip_Mn86478x/Src/apl/: CEC_SampleApl.c Hdmilink.c LP_SampleApl.c mod_ctrl.c SignalGen.c
    ../USER/VideoChip_Mn86478x/Src/: system_func.c
  group MN86478X_CEC
    ../USER/VideoChip_Mn86478x/Src/CEC/cec/api/src/: hdmi_cec_api.c
    ../USER/VideoChip_Mn86478x/Src/CEC/cec/Intr/src/: hdmi_cec_intr.c
    ../USER/VideoChip_Mn86478x/Src/CEC/cec/Manager/src/: hdmi_cec_mrg_main.c hdmi_cec_mrg_reg_acc.c
    ../USER/VideoChip_Mn86478x/Src/CEC/cec/PollingMsg/src/: hdmi_cec_polling_msg.c
    ../USER/VideoChip_Mn86478x/Src/CEC/cec/RxFrame/src/: hdmi_cec_rx_frame.c
    ../USER/VideoChip_Mn86478x/Src/CEC/cec/TxFrame/src/: hdmi_cec_tx_frame.c
    ../USER/VideoChip_Mn86478x/Src/CEC/cec/wrap/src/: hdmi_cec_wrap.c
    ../USER/VideoChip_Mn86478x/Src/CEC/sys/main/src/: hdmi_sys_main.c
    ../USER/VideoChip_Mn86478x/Src/CEC/sys/share/IIC/src/: hdmi_sys_iic.c
    ../USER/VideoChip_Mn86478x/Src/CEC/sys/share/msgevent/src/: hdmi_sys_msgsrv.c
    ../USER/VideoChip_Mn86478x/Src/CEC/sys/share/timer/src/: hdmi_sys_timer.c
    ../USER/VideoChip_Mn86478x/Src/CEC/sys/share/tsksrv/src/: hdmi_sys_tsksrv.c
    ../USER/VideoChip_Mn86478x/Src/CEC/sys/wrap/src/: hdmi_sys_wrap.c
  group MN86478X_HDMIDrv
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/api/: HDMIDrv_api.c HDMIDrv_wrap.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/drvctl/callback/: HDMIDrv_callback_Rep.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/drvctl/: HDMIDrv_drvctl.c HDMIDrv_drvctl_MainReg.c HDMIDrv_drvctl_Rep.c HDMIDrv_drvctl_Rx.c HDMIDrv_drvctl_Tx.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/framework/core/main/: HDMIDrv_fw_main.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/framework/core/share/I2C/: HDMIDrv_fw_i2c.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/framework/core/share/msgevent/: HDMIDrv_fw_msgsrv.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/framework/core/share/SPI/: HDMIDrv_fw_spi.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/framework/core/share/timer/: HDMIDrv_fw_timer.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/framework/core/share/tsksrv/: HDMIDrv_fw_tsksrv.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/framework/wrap/: HDMIDrv_fw_wrap.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/MainRegDriver/core/ake/: HDMIDrv_MainReg_ake.c HDMIDrv_MainReg_ake22.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/MainRegDriver/core/edid/: HDMIDrv_MainReg_setedid.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/MainRegDriver/core/frqchg/: HDMIDrv_MainReg_frqchg.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/MainRegDriver/core/intr/: HDMIDrv_MainReg_intr.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/MainRegDriver/core/main/: HDMIDrv_MainReg_main.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/RxDriver/callback/: HDMIDrv_callback_Rx.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/RxDriver/core/api/: HDMIDrv_Rx_api.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/RxDriver/core/audiocheck/: HDMIDrv_Rx_audiocheck.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/RxDriver/core/intr/: HDMIDrv_Rx_intr.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/RxDriver/core/main/: HDMIDrv_Rx_main.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/RxDriver/core/mute/: HDMIDrv_Rx_mute.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/RxDriver/core/packetcheck/: HDMIDrv_Rx_packetcheck.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/RxDriver/core/videocheck/: HDMIDrv_Rx_videocheck.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/callback/: HDMIDrv_callback_Tx.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/core/api/: HDMIDrv_Tx_api.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/core/AVCTL/: HDMIDrv_Tx_avctl.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/core/DDC/: HDMIDrv_Tx_ddc.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/core/EDID/: HDMIDrv_Tx_edid.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/core/HDCP/: HDMIDrv_Tx_hdcp.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/core/Intr/: HDMIDrv_Tx_intr.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/core/main/: HDMIDrv_Tx_main.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/TxDriver/core/Manager/: HDMIDrv_Tx_mrg_functions.c HDMIDrv_Tx_mrg_hotplug.c HDMIDrv_Tx_mrg_main.c HDMIDrv_Tx_mrg_reg_acc.c HDMIDrv_Tx_mrg_wait_1st_ake.c HDMIDrv_Tx_mrg_wait_edid.c HDMIDrv_Tx_mrg_wait_tx.c
    ../USER/VideoChip_Mn86478x/Src/HDMIDrv/MainRegDriver/callback/: HDMIDrv_callback_MainReg.c
  group Sil9630
    ../USER/external_chip/sii9630/: Sii9630_main.c Sii9630_si_drv_cp8630.c Sii9630_si_drv_sysfs.c Sii9630_si_lib_edid.c Sii9630_si_lib_edid_compose.c Sii9630_si_lib_edid_video_tables.c Sii9630_si_lib_log.c Sii9630_si_lib_video.c Sii9630_si_mod_rx_hdmi.c Sii9630_si_mod_rx_videopath.c Sii9630_si_mod_tx_dsc.c Sii9630_si_mod_tx_hdcp.c Sii9630_si_mod_tx_hdmi.c Sii9630_si_mod_tx_scdc.c Sii9630_si_platform.c Sii9630_si_timer_task.c Sii9630_spiderman.c
  group Gsv
    ../USER/VideoChip_GSV/source/kapi/gsv2k6_gsv2k8_4x4_matrix/: kapi_debug_info.c kernel_fsm.c kernel_status_update.c uapi_function_mapper.c Gsv_kapi.c
    ../USER/VideoChip_GSV/source/uapi/gsv2k6_gsv2k8_4x4_matrix/: gsv2k6.c gsv2k8.c Gsv_hal.c Gsv_uapi.c gsv2k2.c gsv2k11.c gsv2k1.c
    ../USER/VideoChip_GSV/source/userapp/stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404/apps/: av_common.c av_edid_manage.c av_event_handler.c av_irda_cmd.c av_key_cmd.c av_main.c av_uart_cmd.c
    ../USER/VideoChip_GSV/source/userbsp/keil/stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404/: gsv_bsp.c
  group ADI
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/common/cra/: inv_drv_cra.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/common/ipc/: inv_drv_ipc.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/common/ipc_master/: inv_drv_ipc_master.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/common/isp/: inv_drv_isp.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/common/log/: inv_sys_log.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/common/malloc/: inv_sys_malloc.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/common/obj/: inv_sys_obj.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/common/time/: inv_sys_time.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/inv479x/: inv479x.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/inv479x/inv479x_hal/: inv479x_hal.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/platforms/pc/: inv_platform_wrapper.c
    ../USER/VideoChip_ADV/ADV7674/inv_host_drivers/: inv479x_main.c
  group CMSIS_N32G45X
    ../CMSIS_N32G45X/CMSIS/device/: system_n32g45x.c n32g45x_it.c
    ../CMSIS_N32G45X/CMSIS/device/startup/: startup_n32g45x.s
  group N32G45X_LIB
    ../CMSIS_N32G45X/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_xfmc.c
    ../CMSIS_N32G45X/n32g45x_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group CMSIS_GD32F4XX
    ../CMSIS_GDF4XX/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../CMSIS_GDF4XX/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    ../CMSIS_GDF4XX/CMSIS/GD/GD32F4xx/: gd32f4xx_it.c
  group LIB_GD32F4XX
    ../CMSIS_GDF4XX/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group BootFile
    ../boot/: boot.c copy_app.c jump_app.c
  group ALPU
    ../USER/drvAlpu/: alpu.c dmjc.lib
target N32G45X_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
target GD32F4XX_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407
  c misc: --diag_suppress=1293
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target GD32F4XX_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MHD1616S_RX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  AfterMake: HeBin_N32G45X_MHD1616S_RX.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X,_PROJECT_CURRENT_SELECT=_PROJECT_MHD1616S_RX
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
target MHD0404S (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP_0404S.bin "#L"
  AfterMake: HeBin_GD32F4XX_MHD0404S.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_MHD0404S
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MHD0404S_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,DEBUG_MODE_EN,_PROJECT_CURRENT_SELECT=_PROJECT_MHD0404S
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target GD32F4XX_BOOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/Boot.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX;..\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target IMX-25-2VCTAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4XX.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_IMX_25_2VCTAP
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
