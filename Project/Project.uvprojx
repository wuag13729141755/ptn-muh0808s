# Keil uVision project Project.uvprojx, settings and files
target F10xRC_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP.bin "#L"
  AfterMake: HeBin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=1293
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS_F1
    ../CMSIS/CM3/CORE/: core_cm3.c
    ../CMSIS/CM3/STARTUP/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
    ../CMSIS/CM3/: stm32f10x_it.c system_stm32f10x.c
  group CMSIS_F2
    ../CMSIS_F2/CMSIS/CORE/: core_cm3.c
    ../CMSIS_F2/CMSIS/: stm32f2xx_it.c system_stm32f2xx.c
    ../CMSIS_F2/CMSIS/startup/: startup_stm32f2xx.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/flash/: drv_Flash.c
  group BSP
    ../BSP/: bsp.c
  group STLIB_F1
    ../CMSIS/STM32LIB/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_can.c stm32f10x_flash.c
  group STLIB_F2
    ../CMSIS_F2/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FreeRTOS/PortCM4
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group USER
    ../USER/: main.c Task_Led.c Task_Key.c Task_IR.c Task_Eeprom.c Task_Uart.c Task_CEC.c Task_UsbDect.c I2C_Driver.c ITE_comm_api.c SPI_Driver.c Key_Response_Comm.c printf.c Task_CheckChipID.c Task_ExternalChip.c Task_Gsv2kx.c
    ../USER/eeprom/: Eeprom.c
    ../USER/external_chip/: mdrv_ExternalChipDriver.c
    ../USER/Task_Function/: Task_Ms1826.c
  group Gsv
    ../USER/VideoChip_GSV/source/kapi/gsv2k6_gsv2k8_4x4_matrix/: kapi_debug_info.c kernel_fsm.c uapi_function_mapper.c kernel_status_update.c Gsv_kapi.c
    ../USER/VideoChip_GSV/source/uapi/gsv2k6_gsv2k8_4x4_matrix/: gsv2k6.c gsv2k8.c Gsv_hal.c Gsv_uapi.c gsv2k2.c gsv2k11.c gsv2k1.c gsv5k1.c
    ../USER/VideoChip_GSV/source/userapp/stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404/apps/: av_common.c av_edid_manage.c av_event_handler.c av_irda_cmd.c av_key_cmd.c av_main.c av_uart_cmd.c
    ../USER/VideoChip_GSV/source/userbsp/keil/stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404/: gsv_bsp.c
  group CMSIS_N32G45X
    ../CMSIS_N32G45X/CMSIS/device/: system_n32g45x.c n32g45x_it.c
    ../CMSIS_N32G45X/CMSIS/device/startup/: startup_n32g45x.s
  group N32G45X_LIB
    ../CMSIS_N32G45X/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_xfmc.c
    ../CMSIS_N32G45X/n32g45x_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group ALPU_C
    ../USER/drvAlpu/: alpu.c dmjc.lib
  group MS1826
    ../USER/VideoChip_Ms1826/: ms1826_bsp.c ms1826_user_timing_table.c
    ../USER/VideoChip_Ms1826/app/: ms1826_app.c ms1826_app_bypass_mode.c ms1826_app_menuprocess.c ms1826_app_osdprocess.c ms1826_app_single_mode.c ms1826_app_splicer_mode.c ms1826_app_splitter_mode.c ms1826_font.c ms1826_videoprocess.c
    ../USER/VideoChip_Ms1826/sdklib/: MS1826_KEIL_STM32_SDKLIB_M3_V1.34_20230713.lib m3_ms1826_sdklib_20230512.lib
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD, DEBUG_MODE_EN
  c misc: --diag_suppress=1293;
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\pca9539;..\USER\tm1623;..\USER\eeprom;..\USER\video_chip\it66341\IT6634_Customer;..\USER\video_chip\it66341\IT6634_Source;..\USER\video_chip\IT6664;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\external_chip;..\USER\Task_Function\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target SCU41_MV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP_MV.bin "#L"
  AfterMake: HeBin_41MV.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_SCU41_MV
  c misc: --diag_suppress=1293,186
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\video_chip\it66341\IT6634_Customer;..\USER\video_chip\it66341\IT6634_Source;..\USER\video_chip\IT6664;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Ite_InUsbCard.sct
target F2_COMMON (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseF2xx/USERAPP.bin "#L"
  AfterMake: HeBin_F2xx.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX_HD
  c misc: --diag_suppress=1293,186
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\video_chip\it66341\IT6634_Customer;..\USER\video_chip\it66341\IT6634_Source;..\USER\video_chip\IT6664;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\CMSIS_F2\STM32F2xx_StdPeriph_Driver\inc;..\CMSIS_F2\STM32F2x7_ETH_Driver\inc;..\CMSIS_F2\CMSIS\CORE;..\CMSIS_F2\CMSIS\startup;..\CMSIS_F2\CMSIS;..\USER\Task_Function\include;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common\cra;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common\ipc;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common\ipc_master;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common\isp;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common\log;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common\malloc;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common\obj;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common\time;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\common;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\inv479x;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\inv479x\inv479x_hal;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\platforms;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers\platforms\pc;..\USER\VideoChip_ADV\ADV7674\inv_host_drivers
  library: MicroLIB
  memory RVCT4: ROM 0x800d000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target F2_Debug (ARM-ADS)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseF2xx/USERAPP.bin "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX_HD,DEBUG_MODE_EN
  c misc: --diag_suppress=1293,186
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\video_chip\it66341\IT6634_Customer;..\USER\video_chip\it66341\IT6634_Source;..\USER\video_chip\IT6664;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\CMSIS_F2\STM32F2xx_StdPeriph_Driver\inc;..\CMSIS_F2\STM32F2x7_ETH_Driver\inc;..\CMSIS_F2\CMSIS\CORE;..\CMSIS_F2\CMSIS\startup;..\CMSIS_F2\CMSIS;..\USER\VideoChip_Panasonic;..\USER\Task_Function\include;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target F10xRB_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP_RB.bin "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,STM32F10X_RB,
  c misc: --diag_suppress=1293,186
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\video_chip\it66341\IT6634_Customer;..\USER\video_chip\it66341\IT6634_Source;..\USER\video_chip\IT6664;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\Task_Function\include;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\CMSIS\CM3\STARTUP;..\CMSIS\CM3\CORE;..\CMSIS\STM32LIB\inc;..\CMSIS\CM3;..\USER\external_chip\sii9630
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
target N32G45X_Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  AfterMake: HeBin_N32G45X.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\CMSIS_N32G45X\CMSIS\core;..\CMSIS_N32G45X\CMSIS\device;..\CMSIS_N32G45X\n32g45x_usbfs_driver\inc;..\CMSIS_N32G45X\n32g45x_std_periph_driver\inc;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
target N32G45X_Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
target F10XRC_F1H2RX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP.bin "#L"
  AfterMake: HeBin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_FIH2RX
  c misc: --diag_suppress=1293
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv5k1_r1_reg
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target F10XRC_F1H2TX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP.bin "#L"
  AfterMake: HeBin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_FIH2TX
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target F10XRC_IMX-25-2VCTAJ (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP.bin "#L"
  AfterMake: HeBin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_IMX_25_2VCTAJ
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target F10XRC_F1H2TX_V2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP.bin "#L"
  AfterMake: HeBin.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_FIH2TX_V2
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target F10XRC_LMX_4OUHS_C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: USERAPP_4OUHS-C +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP_4OUHS-C.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_LMX_4OUHS_C
  c misc: --diag_suppress=1293,186
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\USER\VideoChip_Ms1826\sdklib;..\USER\VideoChip_Ms1826\app;..\USER\VideoChip_Ms1826
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target F10XRC_LMX_4IUHS_C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP_4IUHS-C.bin "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_LMX_4IUHS_C
  c misc: --diag_suppress=1293,186
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target F10XRC_IMX-25-2VCTAC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: UHD_project +hex
  AfterMake: fromelf.exe --bin -o ../Release/USERAPP.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_IMX_25_2VCTAC
  c misc: --diag_suppress=1293,186
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target F10XRC_MS1826EVB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: UHD_PROJECT +hex
  AfterMake: fromelf.exe --bin -o ../Release/MS1826EVB_USERAPP.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,_PROJECT_CURRENT_SELECT=_PROJECT_MS1826EVB
  c misc: --diag_suppress=1293,186
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
