# Keil uVision project Project_GD32F4XX_ETHNET.uvprojx, settings and files
target N32G45X_Project (ARM-ADS)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  AfterMake: HeBin_N32G45X.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\CMSIS_N32G45X\CMSIS\core;..\CMSIS_N32G45X\CMSIS\device;..\CMSIS_N32G45X\n32g45x_usbfs_driver\inc;..\CMSIS_N32G45X\n32g45x_std_periph_driver\inc;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/flash/: drv_Flash.c
  group BSP
    ../BSP/: bsp.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FreeRTOS/PortCM4
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
  group USER
    ../USER/: main.c Task_Led.c Task_Key.c Task_IR.c Task_Eeprom.c Task_Uart.c Task_CEC.c Task_UsbDect.c I2C_Driver.c ITE_comm_api.c SPI_Driver.c printf.c Task_CheckChipID.c Task_ExternalChip.c Task_Gsv2kx.c Task_Ethernet.c
    ../USER/eeprom/: Eeprom.c
    ../USER/external_chip/: mdrv_ExternalChipDriver.c
    ../USER/Task_Function/: Task_Ms1826.c
  group Gsv
    ../USER/VideoChip_GSV/source/kapi/gsv2k6_gsv2k8_4x4_matrix/: kapi_debug_info.c kernel_fsm.c kernel_status_update.c uapi_function_mapper.c Gsv_kapi.c
    ../USER/VideoChip_GSV/source/uapi/gsv2k6_gsv2k8_4x4_matrix/: gsv2k6.c gsv2k8.c Gsv_hal.c Gsv_uapi.c gsv2k2.c gsv2k11.c gsv2k1.c
    ../USER/VideoChip_GSV/source/userapp/stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404/apps/: av_common.c av_edid_manage.c av_event_handler.c av_irda_cmd.c av_key_cmd.c av_main.c av_uart_cmd.c
    ../USER/VideoChip_GSV/source/userbsp/keil/stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404/: gsv_bsp.c
  group CMSIS_N32G45X
    ../CMSIS_N32G45X/CMSIS/device/: system_n32g45x.c n32g45x_it.c
    ../CMSIS_N32G45X/CMSIS/device/startup/: startup_n32g45x.s
  group N32G45X_LIB
    ../CMSIS_N32G45X/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_xfmc.c
    ../CMSIS_N32G45X/n32g45x_usbfs_driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group CMSIS_GD32F4XX
    ../CMSIS_GDF4XX/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../CMSIS_GDF4XX/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    ../CMSIS_GDF4XX/CMSIS/GD/GD32F4xx/: gd32f4xx_it.c
  group LIB_GD32F4XX
    ../CMSIS_GDF4XX/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group BootFile
    ../boot/: boot.c copy_app.c jump_app.c
  group ALPU
    ../USER/drvAlpu/: alpu.c dmjc.lib
  group Lwip/Api
    ../SYSTEM/Third_Party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/appsSNMP
    ../SYSTEM/Third_Party/lwip-2.1.2/src/apps/snmp/: snmp_asn1.c snmp_core.c snmp_mib2.c snmp_mib2_icmp.c snmp_mib2_interfaces.c snmp_mib2_ip.c snmp_mib2_snmp.c snmp_mib2_system.c snmp_mib2_tcp.c snmp_mib2_udp.c snmp_msg.c snmp_netconn.c snmp_pbuf_stream.c snmp_raw.c snmp_scalar.c snmp_snmpv2_framework.c snmp_snmpv2_usm.c snmp_table.c snmp_threadsync.c snmp_traps.c snmpv3.c snmpv3_mbedtls.c
  group Lwip/appsHTTPD
    ../SYSTEM/Third_Party/lwip-2.1.2/src/apps/http/: altcp_proxyconnect.c fs.c http_client.c httpd.c
  group Lwip/Core
    ../SYSTEM/Third_Party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../SYSTEM/Third_Party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip/Netif
    ../SYSTEM/Third_Party/lwip-2.1.2/src/netif/: bridgeif.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group Lwip/portGD32Basic
    ../SYSTEM/Third_Party/lwip-2.1.2/port/GD32F4xx/Basic/: ethernetif.c
  group Lwip/portGD32FreeRTOS
    ../SYSTEM/Third_Party/lwip-2.1.2/port/GD32F4xx/FreeRTOS/: ethernetif.c sys_arch.c
  group Lwip/portSTM32Basic
    ../SYSTEM/Third_Party/lwip-2.1.2/port/STM32F2x7/Standalone/: ethernetif.c
  group Lwip/portSTM32FreeRTOS
    ../SYSTEM/Third_Party/lwip-2.1.2/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group Ethnet
    ../SYSTEM/ethernet/: lwipconf.c ethnet.c hello_gigadevice.c udp_function.c tcp_function.c snmp_function.c
  group LIB_STM32F2XX
    ../CMSIS_F2/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../CMSIS_F2/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group CMSIS_STM32F20X
    ../CMSIS_F2/CMSIS/: system_stm32f2xx.c stm32f2xx_it.c
    ../CMSIS_F2/CMSIS/startup/: startup_stm32f2xx.s
    ../CMSIS_F2/CMSIS/CORE/: core_cm3.c
  group MS1826
    ../USER/VideoChip_Ms1826/: ms1826_bsp.c ms1826_user_timing_table.c
    ../USER/VideoChip_Ms1826/app/: ms1826_app.c ms1826_app_bypass_mode.c ms1826_app_menuprocess.c ms1826_app_osdprocess.c ms1826_app_single_mode.c ms1826_app_splicer_mode.c ms1826_app_splitter_mode.c ms1826_font.c ms1826_videoprocess.c
    ../USER/VideoChip_Ms1826/sdklib/: MS1826_KEIL_STM32_SDKLIB_M4_V1.34_20230713.lib
target N32G45X_Debug (ARM-ADS)
  device: N32G457REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
target GD32F4XX_Project (ARM-ADS)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407
  c misc: --diag_suppress=1293
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target GD32F4XX_Debug (ARM-ADS)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MHD1616S_RX (ARM-ADS)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  AfterMake: HeBin_N32G45X_MHD1616S_RX.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X,_PROJECT_CURRENT_SELECT=_PROJECT_MHD1616S_RX
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
target MHD0404S (ARM-ADS)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP_0404S.bin "#L"
  AfterMake: HeBin_GD32F4XX_MHD0404S.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_MHD0404S
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MHD0404S_Debug (ARM-ADS)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,DEBUG_MODE_EN,_PROJECT_CURRENT_SELECT=_PROJECT_MHD0404S
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target GD32F4XX_BOOT (ARM-ADS)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: GD32F4XX_BOOTLOAD +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/Boot.bin "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX;..\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target IMX-25-2VCTAP (ARM-ADS)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx_IMX_25_2VCTAP.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_IMX_25_2VCTAP
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX;..\SYSTEM\Third_Party\lwip-2.1.2\src\api;..\SYSTEM\Third_Party\lwip-2.1.2\src\include\;..\SYSTEM\Third_Party\lwip-2.1.2\port\GD32F4xx\;..\SYSTEM\Third_Party\lwip-2.1.2\port\GD32F4xx\Basic;..\SYSTEM\ethernet
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target IMX-25-2VCTAP-STM32F2XX (ARM-ADS)
  device: STM32F207VETx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Ite_spliter_switcher +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx_IMX_25_2VCTAP.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX_HD,_PROJECT_CURRENT_SELECT=_PROJECT_IMX_25_2VCTAP
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX;..\CMSIS_GDF4XX\Third_Party\lwip-2.1.2\src\api;..\CMSIS_GDF4XX\Third_Party\lwip-2.1.2\src\include\;..\CMSIS_GDF4XX\Third_Party\lwip-2.1.2\port\GD32F4xx\;..\CMSIS_GDF4XX\Third_Party\lwip-2.1.2\port\GD32F4xx\Basic;..\SYSTEM\ethernet;..\CMSIS_F2\STM32F2xx_StdPeriph_Driver\inc;..\CMSIS_F2\CMSIS\;..\CMSIS_F2\CMSIS\CORE;..\CMSIS_F2\STM32F2x7_ETH_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target MUH0808S (ARM-ADS)
  device: GD32F407RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: MUH0808S +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx_MUH0808S.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_MUH0808S
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\CMSIS_GDF4XX\CMSIS\GD\GD32F4xx\Include;..\CMSIS_GDF4XX\CMSIS;..\CMSIS_GDF4XX\GD32F4xx_standard_peripheral\Include;..\CMSIS_GDF4XX;..\SYSTEM\Third_Party\lwip-2.1.2\src\api;..\SYSTEM\Third_Party\lwip-2.1.2\src\include\;..\SYSTEM\Third_Party\lwip-2.1.2\port\GD32F4xx\;..\SYSTEM\Third_Party\lwip-2.1.2\port\GD32F4xx\Basic;..\SYSTEM\ethernet;..\USER\VideoChip_Ms1826;..\USER\VideoChip_Ms1826\sdklib;..\USER\VideoChip_Ms1826\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MUH0808S_ETHNET (ARM-ADS)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: MUH0808S +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx_MUH0808S.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_MUH0808S
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MUH0808S_DEBUG (5060528::V5.06 update 5 (build 528)::ARMCLANG)
  device: GD32F407RE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: MUH0808S +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_MUH0808S,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MUH1616S_INPUT (ARM-ADS)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: MUH1616S_INPUT +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx_MUH1616S_INPUT.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_MUH1616S_INPUT
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MUH1616S_INPUT_DEBUG (ARM-ADS)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: MUH1616S_INPUT +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx_MUH1616S_INPUT.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_MUH1616S_INPUT,DEBUG_MODE_EN
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
target MUH1616S_OUTPUT (ARM-ADS)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.0
  cpu: as above
  output: MUH1616S_OUTPUT +hex
  AfterMake: fromelf.exe --bin -o ../ReleaseN32G45X/USERAPP.bin "#L"
  AfterMake: HeBin_N32G45X.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,N32G45X,_PROJECT_CURRENT_SELECT=_PROJECT_MUH1616S_OUTPUT
  c misc: --diag_suppress=1293
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\BSP;..\USER\model_macro;..\USER\external_chip;..\USER\eeprom;..\USER\project_file;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\flash;..\USER\video_chip;..\USER\VideoChip_Mn86478x\Inc;..\USER\VideoChip_Mn86478x\Src\apl;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include;..\USER\VideoChip_Mn86478x\Src\CEC\cec\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Intr\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\Manager\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\PollingMsg\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\RxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\TxFrame\inc;..\USER\VideoChip_Mn86478x\Src\CEC\cec\wrap\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include;..\USER\VideoChip_Mn86478x\Src\CEC\sys\include_share;..\USER\VideoChip_Mn86478x\Src\CEC\sys\main\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\IIC\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\msgevent\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\timer\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\share\tsksrv\inc;..\USER\VideoChip_Mn86478x\Src\CEC\sys\wrap\inc;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\conf;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\drvctl\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\framework\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\MainRegDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\OsdDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\RxDriver\include;..\USER\VideoChip_Mn86478x\Src\HDMIDrv\TxDriver\include;..\USER\external_chip\sii9630;..\USER\VideoChip_GSV\source\kapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_gsv2k8_4x4_matrix;..\USER\VideoChip_GSV\source\uapi\gsv2k6_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k8_r1_reg;..\USER\VideoChip_GSV\source\userapp\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404\apps;..\USER\VideoChip_GSV\source\userbsp\keil\stm32f103ve_gsv2k6_gsv2k8_c_hssuh0404;..\USER\VideoChip_GSV\source\uapi\gsv2k2_r1_reg;..\USER\Task_Function\include;..\CMSIS_N32G45X\CMSIS\core;..\CMSIS_N32G45X\CMSIS\device;..\CMSIS_N32G45X\n32g45x_usbfs_driver\inc;..\CMSIS_N32G45X\n32g45x_std_periph_driver\inc;..\USER\VideoChip_GSV\source\uapi\gsv2k11_r1_reg;..\USER\VideoChip_GSV\source\uapi\gsv2k1_r1_reg;..\USER\VideoChip_Ms1826\sdklib;..\USER\VideoChip_Ms1826\app;..\USER\VideoChip_Ms1826
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
target MUH0808SPro (ARM-ADS)
  device: GD32F427VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: as above
  output: MUH0808S +hex
  AfterMake: fromelf.exe --bin -o ../Release_GD32F4XX/USERAPP.bin "#L"
  AfterMake: HeBin_GD32F4xx_MUH0808S.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F4XX,GD32F407,_PROJECT_CURRENT_SELECT=_PROJECT_MUH0808SPro
  c misc: --diag_suppress=1293
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
